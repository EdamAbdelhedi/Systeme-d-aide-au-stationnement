# Keil uVision project robot.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX
  c include: ..\librairie\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOSV7.4.2\FreeRTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c
  group lib
    ../librairie/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c misc.c
  group system
    ../librairie/STM32F4xx_StdPeriph_Driver/src/: system_stm32f4xx.c
    ../librairie/: startup_stm32f4xx.s
  group FreeRTOS
    ../FreeRTOSV7.4.2/FreeRTOS/Source/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
